# Keil uVision project stc8g1k08a.uvproj, settings and files
target STC8G1K08A (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: main +hex
  c flags: SizeSpeed=1
  c include: .\src
  group Source Group 1
    ./src/: main.c fwid_generated.h
